PROGRAM P_IEC61850MAIN
VAR
END_VAR

fbIEDClient();

END_PROGRAM
